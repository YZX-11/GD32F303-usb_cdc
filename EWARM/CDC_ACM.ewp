# IAR project CDC_ACM.ewp, settings and files
configuration USBD (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xB GD GD32F303xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\GD\GD32F30x\Include; ..\GD32F30x_usbd_library\device\Include; ..\GD32F30x_usbd_library\usbd\Include; ..\GD32F30x_usbd_library\class\device\cdc\Include; ..\Drivers\GD32F30x_standard_peripheral\Include; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: cdc_acm.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliction
    ../src/: gd32f30x_it.c gd32f30x_usbd_hw.c main.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_Peripherals
    ../Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../Drivers/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
  group USBD_Class
    ../GD32F30x_usbd_library/class/device/cdc/Source/: cdc_acm_core.c
  group USBD_Device
    ../GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
